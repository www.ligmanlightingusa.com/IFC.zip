Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-11-22T10:41:47
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: EDB-50021-M-8030
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: EDB-50021-M-8030; Light output ratio: 1; Luminous flux: 741.307 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 741.307 lm; LightEmitterNominalPower: 8 W; Spectrum: 380: 14457, 385: 1398, 390: 13343, 395: 13418, 400: 12377, 405: 12603, 410: 13259, 415: 14275, 420: 17999, 425: 25391, 430: 39557, 435: 658, 440: 13349, 445: 25524, 450: 464, 455: 570347, 460: 530277, 465: 429981, 470: 378694, 475: 328763, 480: 303691, 485: 30493, 490: 339037, 495: 355858, 500: 4025603, 505: 441992, 510: 472424, 515: 49952, 520: 538222, 525: 550136, 530: 574753, 535: 598184, 540: 617614, 545: 641598, 550: 66056, 555: 684892, 560: 710677, 565: 733965, 570: 764085, 575: 799925, 580: 834333, 585: 877809, 590: 892608, 595: 91929, 600: 945643, 605: 967977, 610: 985902, 615: 995899, 620: 999054, 625: 994851, 630: 97972, 635: 959837, 640: 931403, 645: 892768, 650: 845429, 655: 793465, 660: 736654, 665: 678382, 670: 620572, 675: 564233, 680: 511019, 685: 461161, 690: 414114, 695: 362145, 700: 321011, 705: 283907, 710: 245611, 715: 217071, 720: 19102, 725: 167794, 730: 144638, 735: 123196, 740: 108502, 745: 97499, 750: 88019, 755: 81951, 760: 73415, 765: 76564, 770: 68426, 775: 66586, 780: 0; ColorTemperature: 3000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: EDINBURG 3 Floodlights, projectors and column projectors
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 2700K,3000K , 4000K - Die-cast aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Single cable entry - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - High-efficiency PMMA lens - Clear toughened glass - Remote driver (NOT included) - Remote box IP-rated is not included - Plastic ground spike for garden type; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EDB-50021-M-8030; ModelReference: EDINBURG 3 Floodlights, projectors and column projectors; Manufacturer: LIGMAN
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 8 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: EDINBURGH, Floodlights,projectors; Housing color: Not specified
General Information - Weight: 0.7 kg; Case height: 12.6 cm; Case diameter: 6.5 cm; Uld creation date: 22.11.2025 09:41:47
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 8 W
